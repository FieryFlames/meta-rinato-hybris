FILESEXTRAPATHS_prepend_rinato := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE_rinato = "rinato"
