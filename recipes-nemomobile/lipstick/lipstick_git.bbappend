RDEPENDS_${PN}_append_rinato = " qt5-qpa-hwcomposer-plugin "
