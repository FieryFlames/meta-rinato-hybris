FILESEXTRAPATHS_prepend_rinato := "${THISDIR}/${PN}:"
